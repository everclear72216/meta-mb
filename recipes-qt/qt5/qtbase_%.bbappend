PACKAGECONFIG_DISTRO = "gles2 eglfs fontconfig accessibility sql-sqlite tslib"

RDEPENDS_${PN} += "${PN}-conf"
